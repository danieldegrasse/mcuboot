## boot/zephyr/boards/flexboard.conf
```kconfig
CONFIG_BOOT_USB_DFU_KEY=y
CONFIG_BOOT_SIGNATURE_KEY_FILE="../../flexboard-boot-key.pem"
```
